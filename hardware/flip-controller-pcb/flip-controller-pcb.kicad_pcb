# Repository PhilipAnderson/flip

## KiCad design hardware/flip-controller-pcb/flip-controller-pcb.kicad_pcb

Parts:
J1: fsr-connector; PinHeader_2x05_P2.54mm_Vertical
J5: load-cell-input-connector; PinHeader_1x06_P2.54mm_Vertical
J6: load-cell-inputs; PinHeader_1x06_P2.54mm_Vertical
J7: tt-remote; PinHeader_1x06_P2.54mm_Vertical
J8: rfid; PinHeader_1x04_P2.54mm_Vertical
J9: load-cell; PinHeader_1x04_P2.54mm_Vertical
K1, K2: G5V-1; Relay_SPDT_Omron_G5V-1
P1: Digital; Socket_Strip_Arduino_2x18
P2: Power; Socket_Strip_Arduino_1x08
P3, P4: Analog; Socket_Strip_Arduino_1x08
P5: PWM; Socket_Strip_Arduino_1x10
P6: PWM; Socket_Strip_Arduino_1x08
P7: Communication; Socket_Strip_Arduino_1x08
Q1, Q2: BC517; PinHeader_1x03_P2.54mm_Vertical
R7, R8, R9, R10, R11, R12, R13, R14: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal

Connections:
+3V3: J1.4, J1.6, J1.8, J1.10, J8.1, J9.1, P2.4
+5V: J7.5, K1.2, K2.2, P1.35, P1.36, P2.5
/0(Rx0): P6.8
/1(Tx0): P6.7
/2(**): J9.2, P6.6
/3(**): J9.3, P6.5
/4(**): P6.4
/5(**): P6.3
/6(**): P6.2
/7(**): P6.1
/8(**): P5.10, R13.2
/9(**): P5.9, R14.2
/10(**): P5.8
/11(**): P5.7
/12(**): P5.6
/13(**): P5.5
/14(Tx3): P7.1
/15(Rx3): P7.2
/16(Tx2): P7.3
/17(Rx2): P7.4
/18(Tx1): J8.3, P7.5
/19(Rx1): J8.2, P7.6
/20(SDA): P7.7
/21(SCL): P7.8
/22: P1.33
/23: P1.34
/24: P1.31
/25: P1.32
/26: P1.29
/27: P1.30
/28: P1.27
/29: P1.28
/30: P1.25
/31: P1.26
/32: P1.23
/33: P1.24
/34: P1.21
/35: P1.22
/36: P1.19
/37: P1.20
/38: P1.17
/39: P1.18
/40: P1.15
/41: P1.16
/42: P1.13
/43: P1.14
/44: P1.11
/45: P1.12
/46: P1.9
/47: P1.10
/48: P1.7
/49: P1.8
/50(MISO): P1.5
/51(MOSI): P1.6
/52(SCK): P1.3
/53(SS): P1.4
/A0: J1.1, P3.1, R7.1
/A1: J1.3, P3.2, R8.1
/A2: J1.5, P3.3, R9.1
/A3: J1.7, P3.4, R10.1
/A4: J1.9, P3.5, R11.1
/A5: J1.2, P3.6, R12.1
/A6: P3.7
/A7: P3.8
/A8: P4.1
/A9: P4.2
/A10: P4.3
/A11: P4.4
/A12: P4.5
/A13: P4.6
/A14: P4.7
/A15: P4.8
/AREF: P5.3
/IOREF: P2.2
/Reset: P2.3
/SCL: P5.1
/SDA: P5.2
/Vin: P2.8
GND: J7.6, J8.4, J9.4, P1.1, P1.2, P2.6, P2.7, P5.4, Q1.3 (E), Q2.3 (E), R7.2, R8.2, R9.2, R10.2, R11.2, R12.2
unnamed: J5.1, J6.1
unnamed: J5.2, J6.2
unnamed: J5.3, J6.3
unnamed: J5.4, J6.4
unnamed: J5.5, J6.5
unnamed: J5.6, J6.6
unnamed: J7.1, K1.10
unnamed: J7.2, K1.5, K1.6
unnamed: J7.3, K2.5, K2.6
unnamed: J7.4, K2.10
unnamed: K1.9, Q1.1 (C)
unnamed: K2.9, Q2.1 (C)
unnamed: Q1.2 (B), R13.1
unnamed: Q2.2 (B), R14.1

Notes on the sheet:
Shield for Arduino Mega Rev 3
Holes

Board: 2 copper layers, 101.6 x 53.3 mm, 25 parts (0 on the bottom side), 29 nets.

## KiCad design hardware/piezo-controller-pcb/flip-controller.kicad_pcb

Board: 2 copper layers, 82.6 x 53.3 mm, 35 parts (0 on the bottom side), 37 nets.

Parts:
J1: connector_relay_buttons; PinHeader_1x04_P2.54mm_Vertical
J2: connector_vcc_proto; PinHeader_1x04_P2.54mm_Vertical
J3: connector_d8_scl1; PinHeader_1x10_P2.54mm_Vertical
J4: connector_power_lines; PinHeader_1x08_P2.54mm_Vertical
J5: connector_level_converter_3v; PinHeader_1x06_P2.54mm_Vertical
J6: connector_level_converter_5v; PinHeader_1x06_P2.54mm_Vertical
J7: connector_piezos; IDC-Header_2x13_P2.54mm_Vertical
J8: connector_d0_d7; PinHeader_1x08_P2.54mm_Vertical
J9: connector_a0_a7; PinHeader_1x08_P2.54mm_Vertical
J10: connector_rfid_serial; PinHeader_1x04_P2.54mm_Vertical
J11: connector_digital_proto; PinHeader_1x08_P2.54mm_Vertical
J12: connector_d14_d21; PinHeader_1x08_P2.54mm_Vertical
J13: connector_a8_cantx; PinHeader_1x08_P2.54mm_Vertical
J14: connector_analog_proto; PinHeader_1x04_P2.54mm_Vertical
J15: connector_d22_d53; PinHeader_2x18_P2.54mm_Vertical
J16: connector_gnd_proto; PinHeader_1x04_P2.54mm_Vertical
J17, J18, J19, J20, J21: proto; PinHeader_1x19_P2.54mm_Vertical
K1, K2: G5V-1; Relay_SPDT_Omron_G5V-1
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal

Connections:
+3V3: J2.1, J2.2, J2.3, J2.4, J4.4, J5.1
+5V: J4.5, J6.6, J10.1, J15.1, J15.2
GND: J3.7, J4.6, J4.7, J5.6, J6.1, J7.2, J7.4, J7.6, J7.8, J7.10, J7.12, J7.14, J7.16, J7.18, J7.20, J7.22, J7.24, J7.26, J10.2, J15.35, J15.36, J16.1, J16.2, J16.3, J16.4, K1.9, K2.9, R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2
unnamed: J1.1, K2.5, K2.6
unnamed: J1.2, K2.10
unnamed: J1.3, K1.5, K1.6
unnamed: J1.4, K1.10
unnamed: J3.3, J5.5
unnamed: J3.4, J5.4
unnamed: J3.5, K2.2
unnamed: J3.6, K1.2
unnamed: J7.1, J9.1, R1.1
unnamed: J7.3, J9.2, R2.1
unnamed: J7.5, J9.3, R3.1
unnamed: J7.7, J9.4, R4.1
unnamed: J7.9, J9.5, R5.1
unnamed: J7.11, J9.6, R6.1
unnamed: J7.13, J9.7, R7.1
unnamed: J7.15, J9.8, R8.1
unnamed: J6.3, J10.3
unnamed: J6.2, J10.4
unnamed: J11.1, J12.1
unnamed: J11.2, J12.2
unnamed: J11.3, J12.3
unnamed: J11.4, J12.4
unnamed: J11.5, J12.5
unnamed: J11.6, J12.6
unnamed: J11.7, J12.7
unnamed: J11.8, J12.8
unnamed: J7.17, J13.1, R9.1
unnamed: J7.19, J13.2, R10.1
unnamed: J7.21, J13.3, R11.1
unnamed: J7.23, J13.4, R12.1
unnamed: J13.5, J14.4
unnamed: J13.6, J14.3
unnamed: J13.7, J14.2
unnamed: J13.8, J14.1

## Commit log

2021-07-12 Initialize Arduino firmware projects.
2021-07-12 Add hardware files, although they are very unorganized.
2021-07-12 Initialize java applications.
